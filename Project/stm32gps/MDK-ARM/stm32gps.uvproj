# Keil uVision project stm32gps.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32gps +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32_GPS_BOARD_VB, DBG_ENABLE_MACRO
  c include: ..\..\stm32gps;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_GPS;..\..\..\Utilities\STM32_GPS\STM32_GPS_BOARD_VA;..\..\..\Utilities\STM32_GPS\Common;..\..\..\Utilities\SIM800L;..\..\..\Utilities\SIM28M;..\..\..\Utilities\USART;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: main.c stm32f10x_it.c stm32gps_config.c gpio.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group STM32_GPS
    ../../../Utilities/STM32_GPS/: stm32gps_board.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group USART
    ../../../Utilities/USART/: usart.c
  group SIM28M
    ../../../Utilities/SIM28M/: GPS_App.c
  group SIM800L
    ../../../Utilities/SIM800L/: GSM_App.c
target Release (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: stm32gps-realse +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32_GPS_BOARD_VB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target Factory (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: as above
  output: stm32gps-factory +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32_GPS_BOARD_VB, FACTORY_ENABLE_MACRO, DBG_ENABLE_MACRO
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
